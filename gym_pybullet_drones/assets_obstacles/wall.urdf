Commit message: Trying to make own environment

File: gym_pybullet_drones/assets_obstacles/wall.urdf (robot description, URDF)
Before this commit: robot simple_wall, 1 links, 0 joints
Links:
- link wall: geometry collision box size=2.0 0.1 3.0; visual box size=2.0 0.1 3.0
